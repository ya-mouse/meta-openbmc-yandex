PACKAGECONFIG = "zlib ipv6"
