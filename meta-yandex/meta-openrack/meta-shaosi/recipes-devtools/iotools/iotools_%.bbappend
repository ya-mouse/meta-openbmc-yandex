FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://01-compile.patch"
