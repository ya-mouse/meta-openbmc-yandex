# RDEPENDS_${PN}_append = "    "
