FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://mgr-inventory.patch"
