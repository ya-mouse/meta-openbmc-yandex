FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://udhcpc.cfg"
