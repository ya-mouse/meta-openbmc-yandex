FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://obmc-hwmon-sysfs-path.patch"
