FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://obmc-init.sh"
