FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://05-reduce-env-size.patch"
